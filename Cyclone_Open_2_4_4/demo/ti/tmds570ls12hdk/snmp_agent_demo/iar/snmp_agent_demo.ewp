# IAR project snmp_agent_demo.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS1227ZWT TexasInstruments TMS570LS1227ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: _TMS570LS12x_; USE_TMDS570LS12HDK; _CPU_BIG_ENDIAN
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\ti\devices\tms570; ..\..\..\..\..\third_party\ti\boards\tmds570ls12hdk\include; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _TMS570LS12x_; USE_TMDS570LS12HDK; _CPU_BIG_ENDIAN
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: snmp_agent_demo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: tms570ls1227_flash.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: tms570ls1227_sram.icf
  group Demo Sources
    ../src/: main.c private_mib_module.c private_mib_impl.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h private_mib_module.h private_mib_impl.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: tms570_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: dp83640_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_module.c mib2_impl.c mib2_impl_sys.c mib2_impl_if.c mib2_impl_ip.c mib2_impl_tcp.c mib2_impl_udp.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: tms570_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: dp83640_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h mib2_module.h mib2_impl.h mib2_impl_sys.h mib2_impl_if.h mib2_impl_ip.h mib2_impl_tcp.h mib2_impl_udp.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group TMDS570LS12HDK Sources
    ../../../../../third_party/ti/boards/tmds570ls12hdk/source/: dabort.asm errata_SSWF021_45.c esm.c notification.c pinmux.c sci.c system.c sys_core.asm sys_dma.c sys_intvecs.asm sys_mpu.asm sys_pcr.c sys_phantom.c sys_pmm.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c
  group TMDS570LS12HDK Headers
    ../../../../../third_party/ti/boards/tmds570ls12hdk/include/: Device_header.h Device_TMS570LS12.h Device_types.h fee_interface.h adc.h can.h crc.h dcc.h dmm.h emif.h errata_SSWF021_45.h errata_SSWF021_45_defs.h esm.h hal_stdtypes.h het.h htu.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h i2c.h lin.h mibspi.h pinmux.h pom.h reg_adc.h reg_can.h reg_crc.h reg_dcc.h reg_dma.h reg_dmm.h reg_efc.h reg_emif.h reg_esm.h reg_flash.h reg_gio.h reg_het.h reg_htu.h reg_i2c.h reg_lin.h reg_mibspi.h reg_pbist.h reg_pcr.h reg_pinmux.h reg_pmm.h reg_pom.h reg_rti.h reg_rtp.h reg_sci.h reg_spi.h reg_stc.h reg_system.h reg_vim.h rti.h rtp.h sci.h spi.h system.h sys_common.h sys_core.h sys_dma.h sys_mpu.h sys_pcr.h sys_pmm.h sys_pmu.h sys_vim.h MemMap.h std_nhet.h ti_fee.h ti_fee_cfg.h ti_fee_types.h
