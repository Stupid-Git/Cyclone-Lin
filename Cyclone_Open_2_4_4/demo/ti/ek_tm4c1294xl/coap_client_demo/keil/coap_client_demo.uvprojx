# Keil uVision project coap_client_demo.uvprojx, settings and files
target coap_client_demo_flash (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: coap_client_demo_flash
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: PART_TM4C1294NCPDT TARGET_IS_SNOWFLAKE_RA0 USE_EK_TM4C1294XL
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\ti\devices\tm4c129;..\..\..\..\..\third_party\ti\boards\ek_tm4c1294xl;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\tm4c129_flash.sct
  group Demo Sources
    ./: startup_tm4c129.s retarget.c
    ../src/: system_tm4c129.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: tm4c129_eth_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/coap/: coap_client.c coap_client_request.c coap_client_observe.c coap_client_block.c coap_client_transport.c coap_client_misc.c coap_message.c coap_option.c coap_debug.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: tm4c129_eth_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/coap/: coap_client.h coap_client_request.h coap_client_observe.h coap_client_block.h coap_client_transport.h coap_client_misc.h coap_common.h coap_message.h coap_option.h coap_debug.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group EK-TM4C1294XL Sources
    ../../../../../third_party/ti/boards/ek_tm4c1294xl/drivers/: pinout.c
  group EK-TM4C1294XL Headers
    ../../../../../third_party/ti/boards/ek_tm4c1294xl/drivers/: pinout.h
  group Tiva Periph Driver Lib Sources
    ../../../../../third_party/ti/devices/tm4c129/driverlib/: adc.c can.c comp.c cpu.c crc.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Tiva Periph Driver Lib Headers
    ../../../../../third_party/ti/devices/tm4c129/driverlib/: adc.h can.h comp.h cpu.h crc.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h onewire.h pin_map.h pwm.h qei.h rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
target coap_client_demo_sram (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: coap_client_demo_sram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: PART_TM4C1294NCPDT TARGET_IS_SNOWFLAKE_RA0 USE_EK_TM4C1294XL
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\tm4c129_sram.sct
