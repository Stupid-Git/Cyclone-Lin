# IAR project snmp_agent_demo.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LC4357ZWT TexasInstruments TMS570LC4357ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: _TMS570LC43x_; USE_LAUNCHXL2_570LC43; _CPU_BIG_ENDIAN
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\ti\devices\tms570; ..\..\..\..\..\third_party\ti\boards\launchpadxl2_570lc43\include; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _TMS570LC43x_; USE_LAUNCHXL2_570LC43; _CPU_BIG_ENDIAN
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: snmp_agent_demo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: tms570lc4357_flash.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: tms570lc4357_sram.icf
  group Demo Sources
    ../src/: main.c private_mib_module.c private_mib_impl.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h private_mib_module.h private_mib_impl.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: tms570_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: dp83630_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_module.c mib2_impl.c mib2_impl_sys.c mib2_impl_if.c mib2_impl_ip.c mib2_impl_tcp.c mib2_impl_udp.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: tms570_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: dp83630_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h mib2_module.h mib2_impl.h mib2_impl_sys.h mib2_impl_if.h mib2_impl_ip.h mib2_impl_tcp.h mib2_impl_udp.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group LAUNCHPADXL2-570LC43 Sources
    ../../../../../third_party/ti/boards/launchpadxl2_570lc43/source/: HL_epc.c HL_errata.c HL_errata_SSWF021_45.c HL_esm.c HL_gio.c HL_nmpu.c HL_notification.c HL_pinmux.c HL_sci.c HL_system.c HL_sys_core.asm HL_sys_dma.c HL_sys_intvecs.asm HL_sys_mpu.asm HL_sys_pcr.c HL_sys_phantom.c HL_sys_pmm.c HL_sys_pmu.asm HL_sys_startup.c HL_sys_vim.c
  group LAUNCHPADXL2-570LC43 Headers
    ../../../../../third_party/ti/boards/launchpadxl2_570lc43/include/: Device_header.h Device_TMS570LC43.h Device_types.h fee_interface.h HL_adc.h HL_can.h HL_crc.h HL_dcc.h HL_dmm.h HL_ecap.h HL_emif.h HL_epc.h HL_eqep.h HL_errata.h HL_errata_SSWF021_45.h HL_errata_SSWF021_45_defs.h HL_esm.h HL_etpwm.h HL_gio.h HL_hal_stdtypes.h HL_het.h HL_htu.h HL_hw_emac.h HL_hw_emac_ctrl.h HL_hw_mdio.h HL_hw_reg_access.h HL_i2c.h HL_lin.h HL_mibspi.h HL_nmpu.h HL_pinmux.h HL_pom.h HL_reg_adc.h HL_reg_can.h HL_reg_ccmr5.h HL_reg_crc.h HL_reg_dcc.h HL_reg_dma.h HL_reg_dmm.h HL_reg_ecap.h HL_reg_efc.h HL_reg_emif.h HL_reg_epc.h HL_reg_eqep.h HL_reg_esm.h HL_reg_etpwm.h HL_reg_flash.h HL_reg_gio.h HL_reg_het.h HL_reg_htu.h HL_reg_i2c.h HL_reg_l2ramw.h HL_reg_lin.h HL_reg_mibspi.h HL_reg_nmpu.h HL_reg_pbist.h HL_reg_pcr.h HL_reg_pinmux.h HL_reg_pmm.h HL_reg_pom.h HL_reg_rti.h HL_reg_rtp.h HL_reg_sci.h HL_reg_scm.h HL_reg_sdcmmr.h HL_reg_spi.h HL_reg_stc.h HL_reg_system.h HL_reg_vim.h HL_rti.h HL_rtp.h HL_sci.h HL_spi.h HL_system.h HL_sys_common.h HL_sys_core.h HL_sys_dma.h HL_sys_mpu.h HL_sys_pcr.h HL_sys_pmm.h HL_sys_pmu.h HL_sys_vim.h MemMap.h std_nhet.h ti_fee.h ti_fee_cfg.h ti_fee_types.h
