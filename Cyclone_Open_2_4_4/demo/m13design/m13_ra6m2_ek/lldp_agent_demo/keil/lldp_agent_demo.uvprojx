# Keil uVision project lldp_agent_demo.uvprojx, settings and files
target lldp_agent_demo_flash (ARM-ADS)
  device: R7FA6M2AF Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: IROM(0,0x100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: lldp_agent_demo_flash
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BSP_MCU_GROUP_RA6M2 USE_M13_RA6M2_EK
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\renesas\devices\ra;..\..\..\..\..\third_party\renesas\devices\ra\all;..\..\..\..\..\third_party\renesas\devices\ra\ra6m2;..\..\..\..\..\third_party\renesas\devices\ra\fsp\inc;..\..\..\..\..\third_party\renesas\devices\ra\fsp\inc\api;..\..\..\..\..\third_party\m13design\boards\m13_ra6m2_ek;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\gcc\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  asm misc: --cpreproc
  asm include: ..\src
  memory RVCT4: ROM 0x0 size 0x100000
  scatter file: .\ra6m2_flash.sct
  group Demo Sources
    ./: startup_ra6m2.S retarget.c
    ../src/: system_ra6m2.c main.c smi_driver.c debug.c
  group Demo Headers
    ../src/: bsp_irq_cfg.h os_port_config.h net_config.h crypto_config.h FreeRTOSConfig.h smi_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: ra6_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cyclone_tcp/lldp/: lldp.c lldp_ext_dot1.c lldp_ext_dot3.c lldp_ext_med.c lldp_mgmt.c lldp_fsm.c lldp_rx_fsm.c lldp_tx_fsm.c lldp_procedures.c lldp_tlv.c lldp_misc.c lldp_debug.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c snmp_mib_module.c snmp_mib_impl.c lldp_mib_module.c lldp_mib_impl.c lldp_mib_impl_config.c lldp_mib_impl_stats.c lldp_mib_impl_local.c lldp_mib_impl_remote.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: ra6_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h
    ../../../../../cyclone_tcp/lldp/: lldp.h lldp_ext_dot1.h lldp_ext_dot3.h lldp_ext_med.h lldp_mgmt.h lldp_fsm.h lldp_rx_fsm.h lldp_tx_fsm.h lldp_procedures.h lldp_tlv.h lldp_misc.h lldp_debug.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h snmp_mib_module.h snmp_mib_impl.h lldp_mib_module.h lldp_mib_impl.h lldp_mib_impl_config.h lldp_mib_impl_stats.h lldp_mib_impl_local.h lldp_mib_impl_remote.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/gcc/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/gcc/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group M13-RA6M2-EK Headers
    ../../../../../third_party/m13design/boards/m13_ra6m2_ek/: m13_ra6m2_ek.h
target lldp_agent_demo_sram (ARM-ADS)
  device: R7FA6M2AF Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: as above
  output: lldp_agent_demo_sram
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BSP_MCU_GROUP_RA6M2 USE_M13_RA6M2_EK
  c include: as above
  asm misc: --cpreproc
  asm include: ..\src
  memory RVCT4: ROM 0x0 size 0x100000
  scatter file: .\ra6m2_sram.sct
