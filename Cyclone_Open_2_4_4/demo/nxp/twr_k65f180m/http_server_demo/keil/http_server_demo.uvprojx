# Keil uVision project http_server_demo.uvprojx, settings and files
target http_server_demo_flash (ARM-ADS)
  device: MK65FN2M0VMI18 NXP
  pack: NXP.MK65F18_DFP.13.0.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x200000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: http_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MK65FN2M0VMI18 USE_TWR_K65F180M
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\nxp\devices\mk65;..\..\..\..\..\third_party\nxp\devices\mk65\drivers;..\..\..\..\..\third_party\nxp\boards\twr_k65f180m;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mk65f18_flash.sct
  group Demo Sources
    ./: startup_mk65f18.s retarget.c
    ../src/: system_mk65f18.c main.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: mk6x_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8041_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: mk6x_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8041_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group TWR-K65F180M Sources
    ../../../../../third_party/nxp/boards/twr_k65f180m/: clock_config.c pin_mux.c
  group TWR-K65F180M Headers
    ../../../../../third_party/nxp/boards/twr_k65f180m/: board.h clock_config.h peripherals.h pin_mux.h
  group MK65 Drivers Sources
    ../../../../../third_party/nxp/devices/mk65/drivers/: fsl_adc16.c fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_rnga.c fsl_sim.c fsl_smc.c fsl_uart.c
  group MK65 Drivers Headers
    ../../../../../third_party/nxp/devices/mk65/drivers/: fsl_adc16.h fsl_cache.h fsl_clock.h fsl_common.h fsl_gpio.h fsl_port.h fsl_rnga.h fsl_sim.h fsl_smc.h fsl_uart.h
target http_server_demo_sram (ARM-ADS)
  device: MK65FN2M0VMI18 NXP
  pack: NXP.MK65F18_DFP.13.0.0
  cpu: as above
  output: http_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MK65FN2M0VMI18 USE_TWR_K65F180M
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mk65f18_sram.sct
