<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\http_server_demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
