<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\snmp_agent_demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
