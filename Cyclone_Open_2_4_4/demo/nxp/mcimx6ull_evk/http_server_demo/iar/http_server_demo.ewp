# IAR project http_server_demo.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM09; USE_MCIMX6ULL_EVK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\nxp\devices\mcimx6y2; ..\..\..\..\..\third_party\nxp\devices\mcimx6y2\cortexa; ..\..\..\..\..\third_party\nxp\devices\mcimx6y2\drivers; ..\..\..\..\..\third_party\nxp\boards\mcimx6ull_evk; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\arm_ca9; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CPU_MCIMX6Y2DVM09; USE_MCIMX6ULL_EVK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: http_server_demo.bin
  prebuild: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  postbuild: ..\..\..\..\..\third_party\nxp\tools\imgutil\bin\imgutil.exe --combine base_addr=0x60000000 ivt_offset=0x1000 app_offset=0x2000 dcd_file=..\..\..\..\..\third_party\nxp\tools\imgutil\mcimx6ull_evk\dcd.bin app_file=FLASH\Exe\http_server_demo.bin ofile=FLASH\Exe\sdk20-app.img image_entry_point=0x60002000
  ILINK.IlinkOutputFile: http_server_demo.out
  ILINK.IlinkIcfFile: mcimx6y2_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDR (ARM, debug)
  as the first configuration, except:
  postbuild: ..\..\..\..\..\third_party\nxp\tools\imgutil\bin\imgutil.exe --combine base_addr=0x80000000 ivt_offset=0x1000 app_offset=0x2000 dcd_file=..\..\..\..\..\third_party\nxp\tools\imgutil\mcimx6ull_evk\dcd.bin app_file=DDR\Exe\http_server_demo.bin ofile=DDR\Exe\sdk20-app.img image_entry_point=0x80002000
  ILINK.IlinkIcfFile: mcimx6y2_ddr.icf
  group Demo Sources
    ./: startup_mcimx6y2.s
    ../src/: system_mcimx6y2.c main.c smi_driver.c freertos_irq_handler.c fxls8471q.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h smi_driver.h fxls8471q.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: mcimx6ul_eth1_driver.c mcimx6ul_eth2_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: mcimx6ul_eth1_driver.h mcimx6ul_eth2_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/arm_ca9/: port.c portasm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/arm_ca9/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group MCIMX6ULL-EVK Sources
    ../../../../../third_party/nxp/boards/mcimx6ull_evk/: board.c clock_config.c clock_config_ocram.c
  group MCIMX6ULL-EVK Headers
    ../../../../../third_party/nxp/boards/mcimx6ull_evk/: board.h clock_config.h
  group MCIMX6ULL Drivers Sources
    ../../../../../third_party/nxp/devices/mcimx6y2/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_uart.c
  group MCIMX6ULL Drivers Headers
    ../../../../../third_party/nxp/devices/mcimx6y2/drivers/: fsl_cache.h fsl_clock.h fsl_common.h fsl_gpio.h fsl_iomuxc.h fsl_uart.h
