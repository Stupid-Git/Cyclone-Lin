# Keil uVision project http_server_demo.uvprojx, settings and files
target http_server_demo_flash (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.13.0.1
  cpu: IRAM(0x20240000,0x080000) IRAM2(0x202c0000,0x080000) IROM(0x00200000,0x040000) XRAM(0x20340000,0x010000) XRAM2(0x20350000,0x010000) XRAM3(0x20360000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: http_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  AfterMake: fromelf.exe --bincombined --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MIMXRT1176DVMAA_cm7 XIP_EXTERNAL_FLASH=1 XIP_BOOT_HEADER_ENABLE=1 XIP_BOOT_HEADER_DCD_ENABLE=1 CACHE_MODE_WRITE_THROUGH=1 USE_MIMXRT1170_EVK
  c misc: --diag_suppress=66,1296
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\nxp\devices\mimxrt1176;..\..\..\..\..\third_party\nxp\devices\mimxrt1176\drivers;..\..\..\..\..\third_party\nxp\devices\mimxrt1176\drivers\cm7;..\..\..\..\..\third_party\nxp\devices\mimxrt1176\xip;..\..\..\..\..\third_party\nxp\boards\mimxrt1170_evk;..\..\..\..\..\third_party\nxp\boards\mimxrt1170_evk\cm7;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x20340000 size 0x10000
  memory RVCT7: RAM 0x20350000 size 0x10000
  memory RVCT8: RAM 0x20360000 size 0x20000
  memory RVCT9: RAM 0x20240000 size 0x80000
  memory RVCT10: RAM 0x202c0000 size 0x80000
  scatter file: .\mimxrt1176_cm7_flash.sct
  group Demo Sources
    ./: startup_mimxrt1176_cm7.s retarget.c
    ../src/: system_mimxrt1176_cm7.c main.c fxos8700cq.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h fxos8700cq.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: mimxrt1170_eth1_driver.c mimxrt1170_eth2_driver.c mimxrt1170_eth3_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.c rtl8211f_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: mimxrt1170_eth1_driver.h mimxrt1170_eth2_driver.h mimxrt1170_eth3_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8081_driver.h rtl8211f_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group MIMXRT1170-EVK Sources
    ../../../../../third_party/nxp/boards/mimxrt1170_evk/: clock_config.c dcd.c evkmimxrt1170_flexspi_nor_config.c
  group MIMXRT1170-EVK Headers
    ../../../../../third_party/nxp/boards/mimxrt1170_evk/: board.h clock_config.h dcd.h evkmimxrt1170_flexspi_nor_config.h
  group MIMXRT1176 Drivers Sources
    ../../../../../third_party/nxp/devices/mimxrt1176/drivers/: fsl_anatop_ai.c fsl_caam.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_gpio.c fsl_lpuart.c fsl_pmu.c fsl_semc.c
    ../../../../../third_party/nxp/devices/mimxrt1176/drivers/cm7/: fsl_cache.c
  group MIMXRT1176 Drivers Headers
    ../../../../../third_party/nxp/devices/mimxrt1176/drivers/: fsl_anatop_ai.h fsl_caam.h fsl_clock.h fsl_common.h fsl_common_arm.h fsl_dcdc.h fsl_gpio.h fsl_iomuxc.h fsl_lpuart.h fsl_pmu.h fsl_semc.h
    ../../../../../third_party/nxp/devices/mimxrt1176/drivers/cm7/: fsl_cache.h
  group MIMXRT1176 XIP Sources
    ../../../../../third_party/nxp/devices/mimxrt1176/xip/: fsl_flexspi_nor_boot.c
  group MIMXRT1176 XIP Headers
    ../../../../../third_party/nxp/devices/mimxrt1176/xip/: fsl_flexspi_nor_boot.h
target http_server_demo_sram (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.13.0.1
  cpu: as above
  output: http_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MIMXRT1176DVMAA_cm7 CACHE_MODE_WRITE_THROUGH=1 USE_MIMXRT1170_EVK
  c misc: --diag_suppress=66,1296
  c include: as above
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x20340000 size 0x10000
  memory RVCT7: RAM 0x20350000 size 0x10000
  memory RVCT8: RAM 0x20360000 size 0x20000
  memory RVCT9: RAM 0x20240000 size 0x80000
  memory RVCT10: RAM 0x202c0000 size 0x80000
  scatter file: .\mimxrt1176_cm7_sram.sct
target http_server_demo_sdram (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.13.0.1
  cpu: as above
  output: http_server_demo_sdram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MIMXRT1176DVMAA_cm7 SKIP_SYSCLK_INIT CACHE_MODE_WRITE_THROUGH=1 USE_MIMXRT1170_EVK
  c misc: --diag_suppress=66,1296
  c include: as above
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x20340000 size 0x10000
  memory RVCT7: RAM 0x20350000 size 0x10000
  memory RVCT8: RAM 0x20360000 size 0x20000
  memory RVCT9: RAM 0x20240000 size 0x80000
  memory RVCT10: RAM 0x202c0000 size 0x80000
  scatter file: .\mimxrt1176_cm7_sdram.sct
