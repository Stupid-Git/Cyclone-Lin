# Keil uVision project ssh_server_demo.uvprojx, settings and files
target http_client_demo_flash (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.14.0.0
  cpu: IRAM(0x10000000,0x09d800) IRAM2(0x20000000,0x040000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x20040000,0x4000) XRAM2(0x30040000,0x4000) XRAM3(0x04000000,0x8000) XROM(0x00000000,0x09d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: http_client_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1
  c define: CPU_LPC55S69JBD100_cm33_core0 USE_LPCXPRESSO_55S69
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\nxp\devices\lpc55s69;..\..\..\..\..\third_party\nxp\devices\lpc55s69\drivers;..\..\..\..\..\third_party\nxp\boards\lpcxpresso_55s69;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\gcc\arm_cm33_ntz\non_secure;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssh;..\..\..\..\..\cyclone_crypto
  memory RVCT1: ROM 0x0 size 0x9d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x30040000 size 0x4000
  memory RVCT8: RAM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x9d800
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\lpc55s69_cm33_core0_flash.sct
  group Demo Sources
    ./: startup_lpc55s69_cm33_core0.s retarget.c
    ../src/: system_lpc55s69_cm33_core0.c main.c debug.c spi_driver.c ext_int_driver.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h ssh_config.h crypto_config.h FreeRTOSConfig.h spi_driver.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/eth/: lan9250_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/eth/: lan9250_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
  group CycloneSSH Sources
    ../../../../../cyclone_ssh/ssh/: ssh.c ssh_server.c ssh_server_misc.c ssh_algorithms.c ssh_extensions.c ssh_transport.c ssh_kex.c ssh_kex_rsa.c ssh_kex_dh.c ssh_kex_dh_gex.c ssh_kex_ecdh.c ssh_kex_hybrid.c ssh_auth.c ssh_auth_password.c ssh_auth_public_key.c ssh_connection.c ssh_request.c ssh_channel.c ssh_packet.c ssh_key_material.c ssh_exchange_hash.c ssh_modp_groups.c ssh_key_import.c ssh_key_export.c ssh_key_parse.c ssh_key_format.c ssh_key_decrypt.c ssh_key_verify.c ssh_cert_import.c ssh_cert_export.c ssh_cert_parse.c ssh_cert_verify.c ssh_sign_generate.c ssh_sign_verify.c ssh_sign_misc.c ssh_misc.c
    ../../../../../cyclone_ssh/shell/: shell_server.c shell_server_pty.c shell_server_misc.c
  group CycloneSSH Headers
    ../../../../../cyclone_ssh/ssh/: ssh.h ssh_server.h ssh_server_misc.h ssh_algorithms.h ssh_extensions.h ssh_transport.h ssh_kex.h ssh_kex_rsa.h ssh_kex_dh.h ssh_kex_dh_gex.h ssh_kex_ecdh.h ssh_kex_hybrid.h ssh_auth.h ssh_auth_password.h ssh_auth_public_key.h ssh_connection.h ssh_request.h ssh_channel.h ssh_packet.h ssh_key_material.h ssh_exchange_hash.h ssh_modp_groups.h ssh_key_import.h ssh_key_export.h ssh_key_parse.h ssh_key_format.h ssh_key_decrypt.h ssh_key_verify.h ssh_cert_import.h ssh_cert_export.h ssh_cert_parse.h ssh_cert_verify.h ssh_sign_generate.h ssh_sign_verify.h ssh_sign_misc.h ssh_misc.h
    ../../../../../cyclone_ssh/shell/: shell_server.h shell_server_pty.h shell_server_misc.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/lpc55xx/: lpc55s6x_crypto.c lpc55s6x_crypto_trng.c lpc55s6x_crypto_hash.c lpc55s6x_crypto_cipher.c lpc55s6x_crypto_pkc.c
    ../../../../../cyclone_crypto/hash/: md5.c ripemd160.c sha1.c sha256.c sha384.c sha512.c sha3_256.c sha3_512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c cast128.c idea.c des.c des3.c aes.c blowfish.c twofish.c serpent.c camellia.c seed.c chacha.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c ctr.c
    ../../../../../cyclone_crypto/aead/: gcm.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../cyclone_crypto/pqc/: kem.c mlkem768.c mlkem1024.c sntrup761.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/pkix/: pem_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_common.c
    ../../../../../cyclone_crypto/kdf/: pbkdf.c
    ../../../../../cyclone_crypto/xof/: keccak.c shake.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/lpc55xx/: lpc55s6x_crypto.h lpc55s6x_crypto_trng.h lpc55s6x_crypto_hash.h lpc55s6x_crypto_cipher.h lpc55s6x_crypto_pkc.h
    ../../../../../cyclone_crypto/hash/: md5.h ripemd160.h sha1.h sha256.h sha384.h sha512.h sha3_256.h sha3_512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h cast128.h idea.h des.h des3.h aes.h blowfish.h twofish.h serpent.h camellia.h seed.h chacha.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h ctr.h
    ../../../../../cyclone_crypto/aead/: gcm.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../cyclone_crypto/pqc/: kem.h mlkem768.h mlkem1024.h sntrup761.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/pkix/: pem_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_common.h
    ../../../../../cyclone_crypto/kdf/: pbkdf.h
    ../../../../../cyclone_crypto/xof/: keccak.h shake.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: port.c portasm.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group LPCXpresso55S69 Sources
    ../../../../../third_party/nxp/boards/lpcxpresso_55s69/: board.c clock_config.c peripherals.c pin_mux.c
  group LPCXpresso55S69 Headers
    ../../../../../third_party/nxp/boards/lpcxpresso_55s69/: board.h clock_config.h peripherals.h pin_mux.h
  group LPC55S69 Drivers Sources
    ../../../../../third_party/nxp/devices/lpc55s69/drivers/: fsl_casper.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_flexcomm.c fsl_gpio.c fsl_hashcrypt.c fsl_inputmux.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rng.c fsl_spi.c fsl_usart.c
  group LPC55S69 Drivers Headers
    ../../../../../third_party/nxp/devices/lpc55s69/drivers/: fsl_casper.h fsl_clock.h fsl_common.h fsl_common_arm.h fsl_flexcomm.h fsl_hashcrypt.h fsl_inputmux.h fsl_pint.h fsl_power.h fsl_reset.h fsl_rng.h fsl_spi.h fsl_usart.h
target http_client_demo_sram (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.14.0.0
  cpu: as above
  output: http_client_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1
  c define: CPU_LPC55S69JBD100_cm33_core0 USE_LPCXPRESSO_55S69
  c include: as above
  memory RVCT1: ROM 0x0 size 0x9d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x30040000 size 0x4000
  memory RVCT8: RAM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x9d800
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\lpc55s69_cm33_core0_sram.sct
