# Keil uVision project coap_client_demo.uvprojx, settings and files
target coap_client_demo_flash (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  pack: SiliconLabs.EFM32GG11B_DFP.5.7.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: coap_client_demo_flash
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: EFM32GG11B820F2048GL192 USE_EFM32_GIANT_GECKO_11_SK
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\silabs\devices\efm32gg11b;..\..\..\..\..\third_party\silabs\boards\efm32_giant_gecko_11_sk;..\..\..\..\..\third_party\silabs\emlib\inc;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\efm32gg11b_flash.sct
  group Demo Sources
    ./: startup_efm32gg11b.s retarget.c
    ../src/: system_efm32gg11b.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: efm32gg11_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/coap/: coap_client.c coap_client_request.c coap_client_observe.c coap_client_block.c coap_client_transport.c coap_client_misc.c coap_message.c coap_option.c coap_debug.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: efm32gg11_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/coap/: coap_client.h coap_client_request.h coap_client_observe.h coap_client_block.h coap_client_transport.h coap_client_misc.h coap_common.h coap_message.h coap_option.h coap_debug.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group EFM32 Giant Gecko 11 Starter Kit Headers
    ../../../../../third_party/silabs/boards/efm32_giant_gecko_11_sk/: efm32_giant_gecko_11_sk.h
  group EMLIB Sources
    ../../../../../third_party/silabs/emlib/src/: em_assert.c em_cmu.c em_core.c em_crypto.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group EMLIB Headers
    ../../../../../third_party/silabs/emlib/inc/: em_assert.h em_cmu.h em_core.h em_crypto.h em_ebi.h em_emu.h em_gpio.h em_system.h em_usart.h
target coap_client_demo_sram (ARM-ADS)
  device: EFM32GG11B820F2048GL192 Silicon Labs
  pack: SiliconLabs.EFM32GG11B_DFP.5.7.0
  cpu: as above
  output: coap_client_demo_sram
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: EFM32GG11B820F2048GL192 USE_EFM32_GIANT_GECKO_11_SK
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\efm32gg11b_sram.sct
