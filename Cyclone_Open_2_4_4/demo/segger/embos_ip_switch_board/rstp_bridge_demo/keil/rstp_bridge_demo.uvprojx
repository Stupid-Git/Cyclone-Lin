# Keil uVision project rstp_bridge_demo.uvprojx, settings and files
target rstp_bridge_demo_flash (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rstp_bridge_demo_flash
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MK66FN2M0VMD18 USE_EMBOS_IP_SWITCH_BOARD
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\nxp\devices\mk66;..\..\..\..\..\third_party\nxp\devices\mk66\drivers;..\..\..\..\..\third_party\segger\boards\embos_ip_switch_board;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_stp;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mk66f18_flash.sct
  group Demo Sources
    ./: startup_mk66f18.s retarget.c
    ../src/: system_mk66f18.c main.c spi_driver.c debug.c
  group Demo Headers
    ../src/: os_port_config.h stp_config.h net_config.h crypto_config.h FreeRTOSConfig.h spi_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneSTP Sources
    ../../../../../cyclone_stp/rstp/: rstp.c rstp_mgmt.c rstp_fsm.c rstp_bdm.c rstp_pim.c rstp_ppm.c rstp_prs.c rstp_prt.c rstp_prx.c rstp_pst.c rstp_pti.c rstp_ptx.c rstp_tcm.c rstp_procedures.c rstp_conditions.c rstp_bpdu.c rstp_misc.c
    ../../../../../cyclone_stp/mibs/: bridge_mib_module.c bridge_mib_impl.c bridge_mib_impl_base.c bridge_mib_impl_stp.c bridge_mib_impl_tp.c bridge_mib_impl_static.c rstp_mib_module.c rstp_mib_impl.c
  group CycloneSTP Headers
    ../../../../../cyclone_stp/rstp/: rstp.h rstp_mgmt.h rstp_fsm.h rstp_bdm.h rstp_pim.h rstp_ppm.h rstp_prs.h rstp_prt.h rstp_prx.h rstp_pst.h rstp_pti.h rstp_ptx.h rstp_tcm.h rstp_procedures.h rstp_conditions.h rstp_bpdu.h rstp_misc.h
    ../../../../../cyclone_stp/mibs/: bridge_mib_module.h bridge_mib_impl.h bridge_mib_impl_base.h bridge_mib_impl_stp.h bridge_mib_impl_tp.h bridge_mib_impl_static.h rstp_mib_module.h rstp_mib_impl.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: mk6x_eth_driver.c
    ../../../../../cyclone_tcp/drivers/switch/: ksz8794_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c snmp_mib_module.c snmp_mib_impl.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: mk6x_eth_driver.h
    ../../../../../cyclone_tcp/drivers/switch/: ksz8794_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h snmp_mib_module.h snmp_mib_impl.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group embOS IP Switch Board Headers
    ../../../../../third_party/segger/boards/embos_ip_switch_board/: embos_ip_switch_board.h
  group MK66 Drivers Sources
    ../../../../../third_party/nxp/devices/mk66/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_rnga.c fsl_sim.c fsl_smc.c fsl_uart.c
  group MK66 Drivers Headers
    ../../../../../third_party/nxp/devices/mk66/drivers/: fsl_cache.h fsl_clock.h fsl_common.h fsl_gpio.h fsl_port.h fsl_rnga.h fsl_sim.h fsl_smc.h fsl_uart.h
target rstp_bridge_demo_sram (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: as above
  output: rstp_bridge_demo_sram
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MK66FN2M0VMD18 USE_EMBOS_IP_SWITCH_BOARD
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mk66f18_sram.sct
