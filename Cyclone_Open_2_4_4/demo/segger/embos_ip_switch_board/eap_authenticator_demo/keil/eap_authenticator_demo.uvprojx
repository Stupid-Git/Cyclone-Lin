# Keil uVision project eap_authenticator_demo.uvprojx, settings and files
target eap_authenticator_demo_flash (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eap_authenticator_demo_flash
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MK66FN2M0VMD18 USE_EMBOS_IP_SWITCH_BOARD
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\nxp\devices\mk66;..\..\..\..\..\third_party\nxp\devices\mk66\drivers;..\..\..\..\..\third_party\segger\boards\embos_ip_switch_board;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_eap;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mk66f18_flash.sct
  group Demo Sources
    ./: startup_mk66f18.s retarget.c
    ../src/: system_mk66f18.c main.c spi_driver.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h eap_config.h crypto_config.h FreeRTOSConfig.h spi_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: mk6x_eth_driver.c
    ../../../../../cyclone_tcp/drivers/switch/: ksz8794_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c snmp_mib_module.c snmp_mib_impl.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: mk6x_eth_driver.h
    ../../../../../cyclone_tcp/drivers/switch/: ksz8794_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h snmp_mib_module.h snmp_mib_impl.h
  group CycloneEAP Sources
    ../../../../../cyclone_eap/eap/: eap_full_auth_fsm.c eap_auth_procedures.c eap_debug.c
    ../../../../../cyclone_eap/radius/: radius_attributes.c radius_debug.c
    ../../../../../cyclone_eap/authenticator/: authenticator.c authenticator_mgmt.c authenticator_fsm.c authenticator_pae_fsm.c authenticator_backend_fsm.c authenticator_reauth_timer_fsm.c authenticator_procedures.c authenticator_misc.c
    ../../../../../cyclone_eap/mibs/: ieee8021_pae_mib_module.c ieee8021_pae_mib_impl.c ieee8021_pae_mib_impl_sys.c ieee8021_pae_mib_impl_auth.c
  group CycloneEAP Headers
    ../../../../../cyclone_eap/eap/: eap.h eap_full_auth_fsm.h eap_auth_procedures.h eap_debug.h
    ../../../../../cyclone_eap/radius/: radius.h radius_attributes.h radius_debug.h
    ../../../../../cyclone_eap/authenticator/: authenticator.h authenticator_mgmt.h authenticator_fsm.h authenticator_pae_fsm.h authenticator_backend_fsm.h authenticator_reauth_timer_fsm.h authenticator_procedures.h authenticator_misc.h
    ../../../../../cyclone_eap/mibs/: ieee8021_pae_mib_module.h ieee8021_pae_mib_impl.h ieee8021_pae_mib_impl_sys.h ieee8021_pae_mib_impl_auth.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha256.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha256.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group embOS IP Switch Board Headers
    ../../../../../third_party/segger/boards/embos_ip_switch_board/: embos_ip_switch_board.h
  group MK66 Drivers Sources
    ../../../../../third_party/nxp/devices/mk66/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_rnga.c fsl_sim.c fsl_smc.c fsl_uart.c
  group MK66 Drivers Headers
    ../../../../../third_party/nxp/devices/mk66/drivers/: fsl_cache.h fsl_clock.h fsl_common.h fsl_gpio.h fsl_port.h fsl_rnga.h fsl_sim.h fsl_smc.h fsl_uart.h
target eap_authenticator_demo_sram (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: as above
  output: eap_authenticator_demo_sram
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: CPU_MK66FN2M0VMD18 USE_EMBOS_IP_SWITCH_BOARD
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\mk66f18_sram.sct
