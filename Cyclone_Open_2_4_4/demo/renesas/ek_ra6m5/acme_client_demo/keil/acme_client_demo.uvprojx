# Keil uVision project acme_client_demo.uvprojx, settings and files
target acme_client_demo_flash (ARM-ADS)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: acme_client_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BSP_MCU_GROUP_RA6M5 USE_EK_RA6M5 HAVE_STDINT_H
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\renesas\devices\ra;..\..\..\..\..\third_party\renesas\devices\ra\all;..\..\..\..\..\third_party\renesas\devices\ra\ra6m5;..\..\..\..\..\third_party\renesas\devices\ra\fsp\inc;..\..\..\..\..\third_party\renesas\devices\ra\fsp\inc\api;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce\common;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce\crypto_procedures\src\sce9\plainkey\public\inc;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce\crypto_procedures\src\sce9\plainkey\private\inc;..\..\..\..\..\third_party\renesas\boards\ek_ra6m5;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\gcc\ra;..\..\..\..\..\third_party\jansson;..\..\..\..\..\common;..\..\..\..\..\cyclone_acme;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  asm misc: --cpreproc
  asm include: ..\src
  scatter file: .\ra6m5_flash.sct
  group Demo Sources
    ./: startup_ra6m5.S retarget.c
    ../src/: system_ra6m5.c main.c debug.c ext_int_driver.c res.c
  group Demo Headers
    ../src/: bsp_irq_cfg.h os_port_config.h acme_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneACME Sources
    ../../../../../cyclone_acme/acme/: acme_client.c acme_client_directory.c acme_client_nonce.c acme_client_account.c acme_client_order.c acme_client_auth.c acme_client_challenge.c acme_client_certificate.c acme_client_jose.c acme_client_misc.c
  group CycloneACME Headers
    ../../../../../cyclone_acme/acme/: acme_client.h acme_client_directory.h acme_client_nonce.h acme_client_account.h acme_client_order.h acme_client_auth.h acme_client_challenge.h acme_client_certificate.h acme_client_jose.h acme_client_misc.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: ra6_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_client.c http_client_transport.c http_client_misc.c http_server.c http_server_auth.c http_server_misc.c http_common.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: ra6_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_client.h http_client_transport.h http_client_misc.h http_server.h http_server_auth.h http_server_misc.h http_common.h mime.h ssi.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_handshake.c tls_client.c tls_client_fsm.c tls_client_extensions.c tls_client_misc.c tls_server.c tls_server_fsm.c tls_server_extensions.c tls_server_misc.c tls_common.c tls_extensions.c tls_certificate.c tls_sign_generate.c tls_sign_verify.c tls_sign_misc.c tls_key_material.c tls_transcript_hash.c tls_cache.c tls_ticket.c tls_ffdhe.c tls_record.c tls_record_encryption.c tls_record_decryption.c tls_misc.c tls13_client.c tls13_client_extensions.c tls13_client_misc.c tls13_server.c tls13_server_extensions.c tls13_server_misc.c tls13_common.c tls13_sign_generate.c tls13_sign_verify.c tls13_key_material.c tls13_ticket.c tls13_misc.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_handshake.h tls_client.h tls_client_fsm.h tls_client_extensions.h tls_client_misc.h tls_server.h tls_server_fsm.h tls_server_extensions.h tls_server_misc.h tls_common.h tls_extensions.h tls_certificate.h tls_sign_generate.h tls_sign_verify.h tls_sign_misc.h tls_key_material.h tls_transcript_hash.h tls_cache.h tls_ticket.h tls_ffdhe.h tls_record.h tls_record_encryption.h tls_record_decryption.h tls_misc.h tls13_client.h tls13_client_extensions.h tls13_client_misc.h tls13_server.h tls13_server_extensions.h tls13_server_misc.h tls13_common.h tls13_sign_generate.h tls13_sign_verify.h tls13_key_material.h tls13_ticket.h tls13_misc.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/ra6/: ra6_crypto.c ra6_crypto_trng.c ra6_crypto_hash.c ra6_crypto_cipher.c ra6_crypto_pkc.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c base64url.c asn1.c oid.c
    ../../../../../cyclone_crypto/pkix/: pem_import.c pem_export.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c pkcs8_key_format.c x509_key_parse.c x509_key_format.c x509_cert_parse.c x509_cert_ext_parse.c x509_cert_validate.c x509_cert_format.c x509_cert_ext_format.c x509_cert_create.c x509_crl_parse.c x509_crl_ext_parse.c x509_crl_validate.c x509_csr_format.c x509_csr_create.c x509_sign_format.c x509_sign_parse.c x509_sign_generate.c x509_sign_verify.c x509_common.c
    ../../../../../cyclone_crypto/kdf/: hkdf.c pbkdf.c
    ../../../../../cyclone_crypto/xof/: keccak.c shake.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/ra6/: ra6_crypto.h ra6_crypto_trng.h ra6_crypto_hash.h ra6_crypto_cipher.h ra6_crypto_pkc.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h base64url.h asn1.h oid.h
    ../../../../../cyclone_crypto/pkix/: pem_import.h pem_export.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h pkcs8_key_format.h x509_key_parse.h x509_key_format.h x509_cert_parse.h x509_cert_ext_parse.h x509_cert_validate.h x509_cert_format.h x509_cert_ext_format.h x509_cert_create.h x509_crl_parse.h x509_crl_ext_parse.h x509_crl_validate.h x509_csr_format.h x509_csr_create.h x509_sign_format.h x509_sign_parse.h x509_sign_generate.h x509_sign_verify.h x509_common.h
    ../../../../../cyclone_crypto/kdf/: hkdf.h pbkdf.h
    ../../../../../cyclone_crypto/xof/: keccak.h shake.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/gcc/ra/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/gcc/ra/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group Jansson Sources
    ../../../../../third_party/jansson/: dump.c error.c hashtable.c hashtable_seed.c load.c memory.c pack_unpack.c strbuffer.c strconv.c utf.c value.c
  group Jansson Headers
    ../../../../../third_party/jansson/: hashtable.h jansson.h jansson_private.h lookup3.h strbuffer.h utf.h
  group EK-RA6M5 Headers
    ../../../../../third_party/renesas/boards/ek_ra6m5/: ek_ra6m5.h
  group SCE9 Driver Sources
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/adaptors/: r_sce_adapt.c
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/primitive/: hw_sce_p_func000.c hw_sce_p_func001.c hw_sce_p_func002.c hw_sce_p_func027.c hw_sce_p_func028.c hw_sce_p_func031.c hw_sce_p_func043.c hw_sce_p_func044.c hw_sce_p_func048.c hw_sce_p_func049.c hw_sce_p_func050.c hw_sce_p_func051.c hw_sce_p_func052.c hw_sce_p_func053.c hw_sce_p_func054.c hw_sce_p_func057.c hw_sce_p_func058.c hw_sce_p_func059.c hw_sce_p_func060.c hw_sce_p_func061.c hw_sce_p_func062.c hw_sce_p_func063.c hw_sce_p_func064.c hw_sce_p_func065.c hw_sce_p_func066.c hw_sce_p_func067.c hw_sce_p_func068.c hw_sce_p_func070.c hw_sce_p_func071.c hw_sce_p_func074.c hw_sce_p_func075.c hw_sce_p_func076.c hw_sce_p_func077.c hw_sce_p_func080.c hw_sce_p_func081.c hw_sce_p_func082.c hw_sce_p_func100.c hw_sce_p_func101.c hw_sce_p_func102.c hw_sce_p_func103.c hw_sce_p_func200.c hw_sce_p_func202.c hw_sce_p_func205.c hw_sce_p_func206.c hw_sce_p_func207.c hw_sce_p_func300.c hw_sce_p_func301.c hw_sce_p_func302.c hw_sce_p_func304.c hw_sce_p_func307.c hw_sce_p_func308.c hw_sce_p_func309.c hw_sce_p_func310.c hw_sce_p_func311.c hw_sce_p_func312.c hw_sce_p_func313.c hw_sce_p_func314.c hw_sce_p_func315.c hw_sce_p_func316.c hw_sce_p_func317.c hw_sce_p_func318.c hw_sce_p_func319.c hw_sce_p_func320.c hw_sce_p_func321.c hw_sce_p_func322.c hw_sce_p_func323.c hw_sce_p_func324.c hw_sce_p_func325.c hw_sce_p_p00.c hw_sce_p_p01.c hw_sce_p_p02.c hw_sce_p_p07.c hw_sce_p_p08.c hw_sce_p_p15.c hw_sce_p_p16.c hw_sce_p_p17.c hw_sce_p_p20.c hw_sce_p_p21.c hw_sce_p_p26.c hw_sce_p_p29a.c hw_sce_p_p29f.c hw_sce_p_p29i.c hw_sce_p_p29t.c hw_sce_p_p29u.c hw_sce_p_p2b.c hw_sce_p_p32a.c hw_sce_p_p32f.c hw_sce_p_p32i.c hw_sce_p_p32t.c hw_sce_p_p32u.c hw_sce_p_p34a.c hw_sce_p_p34f.c hw_sce_p_p34i.c hw_sce_p_p34t.c hw_sce_p_p34u.c hw_sce_p_p36a.c hw_sce_p_p36f.c hw_sce_p_p36i.c hw_sce_p_p36t.c hw_sce_p_p36u.c hw_sce_p_p40.c hw_sce_p_p41f.c hw_sce_p_p41i.c hw_sce_p_p41u.c hw_sce_p_p44f.c hw_sce_p_p44i.c hw_sce_p_p44u.c hw_sce_p_p47f.c hw_sce_p_p47i.c hw_sce_p_p47u.c hw_sce_p_p50f.c hw_sce_p_p50i.c hw_sce_p_p50u.c hw_sce_p_p56.c hw_sce_p_p57.c hw_sce_p_p6e.c hw_sce_p_p72.c hw_sce_p_p76f.c hw_sce_p_p76i.c hw_sce_p_p76u.c hw_sce_p_p79.c hw_sce_p_p7b.c hw_sce_p_p83a.c hw_sce_p_p83f.c hw_sce_p_p83i.c hw_sce_p_p83t.c hw_sce_p_p83u.c hw_sce_p_p85a.c hw_sce_p_p85f.c hw_sce_p_p85i.c hw_sce_p_p85t.c hw_sce_p_p85u.c hw_sce_p_p89f.c hw_sce_p_p89i.c hw_sce_p_p89u.c hw_sce_p_p92.c hw_sce_p_p95f.c hw_sce_p_p95i.c hw_sce_p_p95u.c hw_sce_p_p98f.c hw_sce_p_p98i.c hw_sce_p_p98u.c hw_sce_p_p9a.c hw_sce_p_p9b.c hw_sce_p_pa1f.c hw_sce_p_pa1i.c hw_sce_p_pa1u.c hw_sce_p_pa4f.c hw_sce_p_pa4i.c hw_sce_p_pa4u.c hw_sce_p_pa7f.c hw_sce_p_pa7i.c hw_sce_p_pa7u.c hw_sce_p_pb0f.c hw_sce_p_pb0i.c hw_sce_p_pb0u.c hw_sce_p_pb3f.c hw_sce_p_pb3i.c hw_sce_p_pb3u.c hw_sce_p_pb6f.c hw_sce_p_pb6i.c hw_sce_p_pb6u.c hw_sce_p_pb9f.c hw_sce_p_pb9i.c hw_sce_p_pb9u.c hw_sce_p_pc2f.c hw_sce_p_pc2i.c hw_sce_p_pc2u.c hw_sce_p_pf0.c hw_sce_p_pf1.c hw_sce_p_pf4.c hw_sce_p_pf5.c hw_sce_p_pf6.c hw_sce_p_pf9.c hw_sce_p_subprc01.c s_flash2.c
  group SCE9 Driver Headers
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/: hw_sce_private.h hw_sce_aes_private.h hw_sce_ecc_private.h hw_sce_hash_private.h hw_sce_rsa_private.h hw_sce_trng_private.h SCE_ProcCommon.h
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/common/: hw_sce_common.h
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/public/inc/: r_sce_if.h
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/private/inc/: hw_sce_ra_private.h SCE_module.h
target acme_client_demo_sram (ARM-ADS)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: as above
  output: acme_client_demo_sram
  BeforeMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BSP_MCU_GROUP_RA6M5 USE_EK_RA6M5 HAVE_STDINT_H
  c include: as above
  asm misc: --cpreproc
  asm include: ..\src
  scatter file: .\ra6m5_sram.sct
