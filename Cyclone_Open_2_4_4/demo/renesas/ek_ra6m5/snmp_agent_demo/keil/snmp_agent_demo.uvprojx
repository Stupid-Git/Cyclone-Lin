# Keil uVision project snmp_agent_demo.uvprojx, settings and files
target snmp_agent_demo_flash (ARM-ADS)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: snmp_agent_demo_flash
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BSP_MCU_GROUP_RA6M5 USE_EK_RA6M5
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\renesas\devices\ra;..\..\..\..\..\third_party\renesas\devices\ra\all;..\..\..\..\..\third_party\renesas\devices\ra\ra6m5;..\..\..\..\..\third_party\renesas\devices\ra\fsp\inc;..\..\..\..\..\third_party\renesas\devices\ra\fsp\inc\api;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce\common;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce\crypto_procedures\src\sce9\plainkey\public\inc;..\..\..\..\..\third_party\renesas\devices\ra\fsp\src\r_sce\crypto_procedures\src\sce9\plainkey\private\inc;..\..\..\..\..\third_party\renesas\boards\ek_ra6m5;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  asm misc: --cpreproc
  asm include: ..\src
  scatter file: .\ra6m5_flash.sct
  group Demo Sources
    ./: startup_ra6m5.S retarget.c
    ../src/: system_ra6m5.c main.c private_mib_module.c private_mib_impl.c debug.c ext_int_driver.c
  group Demo Headers
    ../src/: bsp_irq_cfg.h os_port_config.h net_config.h crypto_config.h private_mib_module.h private_mib_impl.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: ra6_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_module.c mib2_impl.c mib2_impl_sys.c mib2_impl_if.c mib2_impl_ip.c mib2_impl_tcp.c mib2_impl_udp.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: ra6_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h mib2_module.h mib2_impl.h mib2_impl_sys.h mib2_impl_if.h mib2_impl_ip.h mib2_impl_tcp.h mib2_impl_udp.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/ra6/: ra6_crypto.c ra6_crypto_trng.c ra6_crypto_hash.c ra6_crypto_cipher.c ra6_crypto_pkc.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/ra6/: ra6_crypto.h ra6_crypto_trng.h ra6_crypto_hash.h ra6_crypto_cipher.h ra6_crypto_pkc.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group EK-RA6M5 Headers
    ../../../../../third_party/renesas/boards/ek_ra6m5/: ek_ra6m5.h
  group SCE9 Driver Sources
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/adaptors/: r_sce_adapt.c
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/primitive/: hw_sce_p_func000.c hw_sce_p_func001.c hw_sce_p_func002.c hw_sce_p_func027.c hw_sce_p_func028.c hw_sce_p_func031.c hw_sce_p_func043.c hw_sce_p_func044.c hw_sce_p_func048.c hw_sce_p_func049.c hw_sce_p_func050.c hw_sce_p_func051.c hw_sce_p_func052.c hw_sce_p_func053.c hw_sce_p_func054.c hw_sce_p_func057.c hw_sce_p_func058.c hw_sce_p_func059.c hw_sce_p_func060.c hw_sce_p_func061.c hw_sce_p_func062.c hw_sce_p_func063.c hw_sce_p_func064.c hw_sce_p_func065.c hw_sce_p_func066.c hw_sce_p_func067.c hw_sce_p_func068.c hw_sce_p_func070.c hw_sce_p_func071.c hw_sce_p_func074.c hw_sce_p_func075.c hw_sce_p_func076.c hw_sce_p_func077.c hw_sce_p_func080.c hw_sce_p_func081.c hw_sce_p_func082.c hw_sce_p_func100.c hw_sce_p_func101.c hw_sce_p_func102.c hw_sce_p_func103.c hw_sce_p_func200.c hw_sce_p_func202.c hw_sce_p_func205.c hw_sce_p_func206.c hw_sce_p_func207.c hw_sce_p_func300.c hw_sce_p_func301.c hw_sce_p_func302.c hw_sce_p_func304.c hw_sce_p_func307.c hw_sce_p_func308.c hw_sce_p_func309.c hw_sce_p_func310.c hw_sce_p_func311.c hw_sce_p_func312.c hw_sce_p_func313.c hw_sce_p_func314.c hw_sce_p_func315.c hw_sce_p_func316.c hw_sce_p_func317.c hw_sce_p_func318.c hw_sce_p_func319.c hw_sce_p_func320.c hw_sce_p_func321.c hw_sce_p_func322.c hw_sce_p_func323.c hw_sce_p_func324.c hw_sce_p_func325.c hw_sce_p_p00.c hw_sce_p_p01.c hw_sce_p_p02.c hw_sce_p_p07.c hw_sce_p_p08.c hw_sce_p_p15.c hw_sce_p_p16.c hw_sce_p_p17.c hw_sce_p_p20.c hw_sce_p_p21.c hw_sce_p_p26.c hw_sce_p_p29a.c hw_sce_p_p29f.c hw_sce_p_p29i.c hw_sce_p_p29t.c hw_sce_p_p29u.c hw_sce_p_p2b.c hw_sce_p_p32a.c hw_sce_p_p32f.c hw_sce_p_p32i.c hw_sce_p_p32t.c hw_sce_p_p32u.c hw_sce_p_p34a.c hw_sce_p_p34f.c hw_sce_p_p34i.c hw_sce_p_p34t.c hw_sce_p_p34u.c hw_sce_p_p36a.c hw_sce_p_p36f.c hw_sce_p_p36i.c hw_sce_p_p36t.c hw_sce_p_p36u.c hw_sce_p_p40.c hw_sce_p_p41f.c hw_sce_p_p41i.c hw_sce_p_p41u.c hw_sce_p_p44f.c hw_sce_p_p44i.c hw_sce_p_p44u.c hw_sce_p_p47f.c hw_sce_p_p47i.c hw_sce_p_p47u.c hw_sce_p_p50f.c hw_sce_p_p50i.c hw_sce_p_p50u.c hw_sce_p_p56.c hw_sce_p_p57.c hw_sce_p_p6e.c hw_sce_p_p72.c hw_sce_p_p76f.c hw_sce_p_p76i.c hw_sce_p_p76u.c hw_sce_p_p79.c hw_sce_p_p7b.c hw_sce_p_p83a.c hw_sce_p_p83f.c hw_sce_p_p83i.c hw_sce_p_p83t.c hw_sce_p_p83u.c hw_sce_p_p85a.c hw_sce_p_p85f.c hw_sce_p_p85i.c hw_sce_p_p85t.c hw_sce_p_p85u.c hw_sce_p_p89f.c hw_sce_p_p89i.c hw_sce_p_p89u.c hw_sce_p_p92.c hw_sce_p_p95f.c hw_sce_p_p95i.c hw_sce_p_p95u.c hw_sce_p_p98f.c hw_sce_p_p98i.c hw_sce_p_p98u.c hw_sce_p_p9a.c hw_sce_p_p9b.c hw_sce_p_pa1f.c hw_sce_p_pa1i.c hw_sce_p_pa1u.c hw_sce_p_pa4f.c hw_sce_p_pa4i.c hw_sce_p_pa4u.c hw_sce_p_pa7f.c hw_sce_p_pa7i.c hw_sce_p_pa7u.c hw_sce_p_pb0f.c hw_sce_p_pb0i.c hw_sce_p_pb0u.c hw_sce_p_pb3f.c hw_sce_p_pb3i.c hw_sce_p_pb3u.c hw_sce_p_pb6f.c hw_sce_p_pb6i.c hw_sce_p_pb6u.c hw_sce_p_pb9f.c hw_sce_p_pb9i.c hw_sce_p_pb9u.c hw_sce_p_pc2f.c hw_sce_p_pc2i.c hw_sce_p_pc2u.c hw_sce_p_pf0.c hw_sce_p_pf1.c hw_sce_p_pf4.c hw_sce_p_pf5.c hw_sce_p_pf6.c hw_sce_p_pf9.c hw_sce_p_subprc01.c s_flash2.c
  group SCE9 Driver Headers
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/: hw_sce_private.h hw_sce_aes_private.h hw_sce_ecc_private.h hw_sce_hash_private.h hw_sce_rsa_private.h hw_sce_trng_private.h SCE_ProcCommon.h
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/common/: hw_sce_common.h
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/public/inc/: r_sce_if.h
    ../../../../../third_party/renesas/devices/ra/fsp/src/r_sce/crypto_procedures/src/sce9/plainkey/private/inc/: hw_sce_ra_private.h SCE_module.h
target snmp_agent_demo_sram (ARM-ADS)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: as above
  output: snmp_agent_demo_sram
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BSP_MCU_GROUP_RA6M5 USE_EK_RA6M5
  c include: as above
  asm misc: --cpreproc
  asm include: ..\src
  scatter file: .\ra6m5_sram.sct
