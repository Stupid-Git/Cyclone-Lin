# IAR project https_client_demo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F565NE R5F565NE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x20000
  ICCRX.CCDefines: USE_RSK_RX65N_2M
  ICCRX.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\Config_PORT; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\Config_SCI6; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\Config_SCI8; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\Config_CMT0; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\Config_CMT2; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\general; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\r_bsp; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\r_config; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\r_pincfg; ..\..\..\..\..\third_party\renesas\boards\rsk_rx65n_2m\smc_gen\r_tsip_rx; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\rx600v2; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: ..\src
  ILINK.IlinkOutputFile: https_client_demo.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  group Demo Sources
    ../src/: main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: rx65n_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: dp83620_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_client.c http_client_transport.c http_client_misc.c http_common.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: rx65n_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: dp83620_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_client.h http_client_transport.h http_client_misc.h http_common.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_handshake.c tls_client.c tls_client_fsm.c tls_client_extensions.c tls_client_misc.c tls_server.c tls_server_fsm.c tls_server_extensions.c tls_server_misc.c tls_common.c tls_extensions.c tls_certificate.c tls_sign_generate.c tls_sign_verify.c tls_sign_misc.c tls_key_material.c tls_transcript_hash.c tls_cache.c tls_ticket.c tls_ffdhe.c tls_record.c tls_record_encryption.c tls_record_decryption.c tls_misc.c tls13_client.c tls13_client_extensions.c tls13_client_misc.c tls13_server.c tls13_server_extensions.c tls13_server_misc.c tls13_common.c tls13_sign_generate.c tls13_sign_verify.c tls13_key_material.c tls13_ticket.c tls13_misc.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_handshake.h tls_client.h tls_client_fsm.h tls_client_extensions.h tls_client_misc.h tls_server.h tls_server_fsm.h tls_server_extensions.h tls_server_misc.h tls_common.h tls_extensions.h tls_certificate.h tls_sign_generate.h tls_sign_verify.h tls_sign_misc.h tls_key_material.h tls_transcript_hash.h tls_cache.h tls_ticket.h tls_ffdhe.h tls_record.h tls_record_encryption.h tls_record_decryption.h tls_misc.h tls13_client.h tls13_client_extensions.h tls13_client_misc.h tls13_server.h tls13_server_extensions.h tls13_server_misc.h tls13_common.h tls13_sign_generate.h tls13_sign_verify.h tls13_key_material.h tls13_ticket.h tls13_misc.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/rx65n/: rx65n_crypto.c rx65n_crypto_trng.c rx65n_crypto_hash.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/pkix/: pem_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_ext_parse.c x509_cert_validate.c x509_crl_parse.c x509_crl_ext_parse.c x509_crl_validate.c x509_sign_parse.c x509_sign_verify.c x509_common.c
    ../../../../../cyclone_crypto/kdf/: hkdf.c pbkdf.c
    ../../../../../cyclone_crypto/xof/: keccak.c shake.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/rx65n/: rx65n_crypto.h rx65n_crypto_trng.h rx65n_crypto_hash.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/pkix/: pem_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_cert_parse.h x509_cert_ext_parse.h x509_cert_validate.h x509_crl_parse.h x509_crl_ext_parse.h x509_crl_validate.h x509_sign_parse.h x509_sign_verify.h x509_common.h
    ../../../../../cyclone_crypto/kdf/: hkdf.h pbkdf.h
    ../../../../../cyclone_crypto/xof/: keccak.h shake.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/rx600v2/: port.c port_asm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/rx600v2/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group RSK-RX65N-2M Sources
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/: ascii.c r_okaya_lcd.c
  group RSK-RX65N-2M Headers
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/: ascii.h rskrx65n2mbdef.h r_okaya_lcd.h
  group TSIP Driver Sources
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_tsip_rx/lib/iar/: r_tsip_rx65n_little.lib
  group TSIP Driver Headers
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_tsip_rx/: r_tsip_rx_if.h
  group RX65N Drivers Sources
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_CMT0/: Config_CMT0.c Config_CMT0_user.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_CMT2/: Config_CMT2.c Config_CMT2_user.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_PORT/: Config_PORT.c Config_PORT_user.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_SCI6/: Config_SCI6.c Config_SCI6_user.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_SCI8/: Config_SCI8.c Config_SCI8_user.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/general/: r_cg_hardware_setup.c r_smc_cgc.c r_smc_cgc_user.c r_smc_interrupt.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/board/generic_rx65n/: hwsetup.c resetprg.c vecttbl.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/mcu/all/: r_bsp_common.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/mcu/rx65n/: cpu.c locking.c mcu_clocks.c mcu_init.c mcu_interrupts.c mcu_locks.c mcu_mapped_interrupts.c
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_pincfg/: Pin.c
  group RX65N Drivers Headers
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_CMT0/: Config_CMT0.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_CMT2/: Config_CMT2.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_PORT/: Config_PORT.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_SCI6/: Config_SCI6.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/Config_SCI8/: Config_SCI8.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/general/: r_cg_cmt.h r_cg_cmtw.h r_cg_macrodriver.h r_cg_port.h r_cg_rspi.h r_cg_sci.h r_cg_userdefine.h r_smc_cgc.h r_smc_entry.h r_smc_interrupt.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/: platform.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/board/generic_rx65n/: hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h vecttbl.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/mcu/all/: r_bsp_common.h r_typedefs.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/mcu/rx65n/: cpu.h locking.h mcu_info.h mcu_init.h mcu_interrupts.h mcu_locks.h mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_bsp/mcu/rx65n/register_access/: iodefine.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_config/: r_bsp_config.h r_bsp_interrupt_config.h
    ../../../../../third_party/renesas/boards/rsk_rx65n_2m/smc_gen/r_pincfg/: Pin.h
