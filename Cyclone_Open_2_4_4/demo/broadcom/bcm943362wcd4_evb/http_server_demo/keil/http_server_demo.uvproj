# Keil uVision project http_server_demo.uvproj, settings and files
target http_server_demo_flash (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: http_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX USE_STDPERIPH_DRIVER USE_BCM943362WCD4_EVB WICED_DISABLE_BOOTLOADER WWD_STARTUP_DELAY=10 HSE_VALUE=26000000
  c misc: --gnu --diag_suppress 188
  c include: ..\src;..\..\..\..\..\third_party\broadcom\wiced_sdk\include;..\..\..\..\..\third_party\broadcom\wiced_sdk\libraries\filesystems\wicedfs\src;..\..\..\..\..\third_party\broadcom\wiced_sdk\libraries\inputs\gpio_button;..\..\..\..\..\third_party\broadcom\wiced_sdk\libraries\utilities\ring_buffer;..\..\..\..\..\third_party\broadcom\wiced_sdk\libraries\utilities\tlv;..\..\..\..\..\third_party\broadcom\wiced_sdk\platforms\bcm943362wcd4;..\..\..\..\..\third_party\broadcom\wiced_sdk\resource;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\network\nons\wwd;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\platform\arm_cm3;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\platform\gcc;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\platform\include;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\platform\mcu;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\platform\mcu\stm32f2xx;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\platform\mcu\stm32f2xx\peripherals;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\rtos\freertos\wwd;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\rtos\freertos\wwd\arm_cm3;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\security\besl\include;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\include;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\include\network;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\include\platform;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\include\rtos;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\internal\bus_protocols;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\internal\bus_protocols\sdio;..\..\..\..\..\third_party\broadcom\wiced_sdk\wiced\wwd\internal\chips\43362;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\st\devices\stm32f2xx;..\..\..\..\..\third_party\st\drivers\stm32f2xx_std_periph_lib\inc;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm3;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32f205_flash.sct
  group Demo Sources
    ./: startup_stm32f2xx.s retarget.c
    ../src/: system_stm32f2xx.c stm32f2xx_it.c main.c wwd_buffer.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h stm32f2xx_conf.h stm32f2xx_it.h wwd_buffer.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/wifi/: bcm43362_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c ndp_router_adv_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_server.c dhcp_server_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/wifi/: bcm43362_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h ndp_router_adv.h ndp_router_adv_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_server.h dhcp_server_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group WICED Sources
    ../../../../../third_party/broadcom/wiced_sdk/libraries/utilities/ring_buffer/: ring_buffer.c
    ../../../../../third_party/broadcom/wiced_sdk/libraries/utilities/tlv/: tlv.c
    ../../../../../third_party/broadcom/wiced_sdk/platforms/bcm943362wcd4/: platform.c
    ../../../../../third_party/broadcom/wiced_sdk/resources/: 43362A2_bin.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/platform/mcu/: platform_resource.c platform_stdio.c wwd_platform_separate_mcu.c wwd_resources.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/platform/mcu/stm32f2xx/: platform_init.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/platform/mcu/stm32f2xx/peripherals/: platform_gpio.c platform_mcu_powersave.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/platform/mcu/stm32f2xx/wwd/: wwd_platform.c wwd_sdio.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/rtos/freertos/wwd/: wwd_rtos.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/rtos/freertos/wwd/arm_cm3/: low_level_init.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/wwd/internal/bus_protocols/sdio/: wwd_bus_protocol.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/wwd/internal/bus_protocols/: wwd_bus_common.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/wwd/internal/chips/43362/: wwd_ap.c wwd_chip_specific_functions.c
    ../../../../../third_party/broadcom/wiced_sdk/wiced/wwd/internal/: wwd_eapol.c wwd_internal.c wwd_logging.c wwd_management.c wwd_sdpcm.c wwd_thread.c wwd_thread_internal.c wwd_wifi.c
  group WICED Headers
    ../../../../../third_party/broadcom/wiced_sdk/wiced/wwd/internal/bus_protocols/sdio/: wwd_bus_protocol.h
    ../../../../../third_party/broadcom/wiced_sdk/wiced/wwd/internal/bus_protocols/: wwd_bus_protocol_interface.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm3/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm3/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32F2xx Std Periph Lib Sources
    ../../../../../third_party/st/drivers/stm32f2xx_std_periph_lib/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32F2xx Std Periph Lib Headers
    ../../../../../third_party/st/drivers/stm32f2xx_std_periph_lib/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
target http_server_demo_sram (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: as above
  output: http_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1
  c define: as above
  c misc: --gnu --diag_suppress 188
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32f205_sram.sct
