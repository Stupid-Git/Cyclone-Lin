# Keil uVision project snmp_agent_demo.uvprojx, settings and files
target snmp_agent_demo_flash (ARM-ADS)
  device: ATSAME54P20A Atmel
  pack: Microchip.SAME54_DFP.3.7.122
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: snmp_agent_demo_flash
  c flags: Optim=1 OneElfS=1
  c define: __SAME54P20A__ USE_CMSIS_INIT USE_SAME54_XPLAINED_PRO
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\microchip\devices\same54;..\..\..\..\..\third_party\microchip\boards\same54_xplained_pro;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\same54_flash.sct
  group Demo Sources
    ./: startup_same54.s retarget.c
    ../src/: system_same54.c main.c private_mib_module.c private_mib_impl.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h private_mib_module.h private_mib_impl.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: same54_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_module.c mib2_impl.c mib2_impl_sys.c mib2_impl_if.c mib2_impl_ip.c mib2_impl_tcp.c mib2_impl_udp.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: same54_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h mib2_module.h mib2_impl.h mib2_impl_sys.h mib2_impl_if.h mib2_impl_ip.h mib2_impl_tcp.h mib2_impl_udp.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/same54/: same54_crypto.c same54_crypto_trng.c same54_crypto_hash.c same54_crypto_cipher.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/same54/: same54_crypto.h same54_crypto_trng.h same54_crypto_hash.h same54_crypto_cipher.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group SAME54-Xplained-Pro Headers
    ../../../../../third_party/microchip/boards/same54_xplained_pro/: same54_xplained_pro.h
target snmp_agent_demo_sram (ARM-ADS)
  device: ATSAME54P20A Atmel
  pack: Microchip.SAME54_DFP.3.7.122
  cpu: as above
  output: snmp_agent_demo_sram
  c flags: Optim=1 OneElfS=1
  c define: __SAME54P20A__ USE_CMSIS_INIT USE_SAME54_XPLAINED_PRO
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\same54_sram.sct
