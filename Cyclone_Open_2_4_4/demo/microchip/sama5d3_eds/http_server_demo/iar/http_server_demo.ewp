# IAR project http_server_demo.ewp, settings and files
configuration DDRAM (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D35 Atmel ATSAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SAMA5D36; USE_SAMA5D3_EDS; USE_KSZ9893
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\microchip\devices\sama5d3x; ..\..\..\..\..\third_party\microchip\boards\sama5d3_eds; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\arm_ca5_no_gic; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SAMA5D36; USE_SAMA5D3_EDS; USE_KSZ9893
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: http_server_demo.srec
  prebuild: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  ILINK.IlinkOutputFile: http_server_demo.out
  ILINK.IlinkIcfFile: sama5d3x_ddram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sama5d3x_sram.icf
configuration NOR FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sama5d3x_norflash.icf
  group Demo Sources
    ./: board_cstartup_iar.s cp15_asm_iar.s
    ../src/: board_lowlevel.c board_memories.c aic.c cp15.c mmu.c pit.c pmc.c wdt.c main.c freertos_tick_config.c freertos_irq_handler.c spi0_driver.c spi1_driver.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h FreeRTOSConfig.h board_lowlevel.h cp15.h irq.h mmu.h pit.h pmc.h wdt.h spi0_driver.h spi1_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: sama5d3_eth1_driver.c sama5d3_eth2_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz9131_driver.c lan8830_driver.c lan8841_driver.c
    ../../../../../cyclone_tcp/drivers/switch/: ksz8563_driver.c ksz8863_driver.c ksz9563_driver.c ksz9893_driver.c lan9303_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: sama5d3_eth1_driver.h sama5d3_eth2_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz9131_driver.h lan8830_driver.h lan8841_driver.h
    ../../../../../cyclone_tcp/drivers/switch/: ksz8563_driver.h ksz8863_driver.h ksz9563_driver.h ksz9893_driver.h lan9303_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/sama5d3/: sama5d3_crypto.c sama5d3_crypto_trng.c
    ../../../../../cyclone_crypto/hash/: md5.c
    ../../../../../cyclone_crypto/encoding/: base64.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/sama5d3/: sama5d3_crypto.h sama5d3_crypto_trng.h
    ../../../../../cyclone_crypto/hash/: md5.h
    ../../../../../cyclone_crypto/encoding/: base64.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/iar/arm_ca5_no_gic/: port.c portasm.s
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/iar/arm_ca5_no_gic/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group SAMA5D3-EDS Headers
    ../../../../../third_party/microchip/boards/sama5d3_eds/: sama5d3_eds.h
