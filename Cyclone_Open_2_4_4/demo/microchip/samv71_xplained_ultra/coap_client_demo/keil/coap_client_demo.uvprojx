# Keil uVision project coap_client_demo.uvprojx, settings and files
target coap_client_demo_flash (ARM-ADS)
  device: ATSAMV71Q21B Microchip
  pack: Microchip.SAMV71_DFP.4.8.113
  cpu: IRAM(0x20400000,0x00060000) IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: coap_client_demo_flash
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __SAMV71Q21B__ USE_CMSIS_INIT USE_SAMV71_XPLAINED_ULTRA
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\microchip\devices\samv71;..\..\..\..\..\third_party\microchip\boards\samv71_xplained_ultra;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\samv71_flash.sct
  group Demo Sources
    ./: startup_samv71.s samv71_gpnvm.s retarget.c
    ../src/: system_samv71.c main.c debug.c ext_int_driver.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: samv71_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: ksz8061_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/coap/: coap_client.c coap_client_request.c coap_client_observe.c coap_client_block.c coap_client_transport.c coap_client_misc.c coap_message.c coap_option.c coap_debug.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: samv71_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: ksz8061_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/coap/: coap_client.h coap_client_request.h coap_client_observe.h coap_client_block.h coap_client_transport.h coap_client_misc.h coap_common.h coap_message.h coap_option.h coap_debug.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group SAMV71-Xplained-Ultra Headers
    ../../../../../third_party/microchip/boards/samv71_xplained_ultra/: samv71_xplained_ultra.h
target coap_client_demo_sram (ARM-ADS)
  device: ATSAMV71Q21B Microchip
  pack: Microchip.SAMV71_DFP.4.8.113
  cpu: as above
  output: coap_client_demo_sram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __SAMV71Q21B__ USE_CMSIS_INIT USE_SAMV71_XPLAINED_ULTRA
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\samv71_sram.sct
